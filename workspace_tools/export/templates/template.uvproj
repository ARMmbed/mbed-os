# Keil uVision project template.uvproj, settings and files
target lpc1768_blinky (ARM-ADS)
  device: STM32F439ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: lpc1768_blinky
  c flags: Optim=2 uC99=1
  c define: TARGET_LPC1768, TARGET_M3, TARGET_NXP, __CORTEX_M3, __MBED__=1, TOOLCHAIN_ARM_STD, __ASSERT_MSG, TOOLCHAIN_ARM
  c misc: --no_rtti --debug -g --gnu
  c include: ..\..\mbed\libraries\mbed\targets\cmsis; ..\..\mbed\libraries\mbed\targets\cmsis\TARGET_NXP\TARGET_LPC176X; ..\..\examples\blinky; ..\..\mbed\libraries\mbed\api; ..\..\mbed\libraries\mbed\common; ..\..\mbed\libraries\mbed\hal; ..\..\mbed\libraries\mbed\targets\hal\TARGET_NXP\TARGET_LPC176X; ..\..\mbed\libraries\mbed\targets\hal\TARGET_NXP\TARGET_LPC176X\TARGET_MBED_LPC1768
  asm define: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\mbed\libraries\mbed\targets\cmsis\TARGET_NXP\TARGET_LPC176X\TOOLCHAIN_ARM_STD\LPC1768.sct
  group default
    ../../mbed/libraries/mbed/targets/cmsis/TARGET_NXP/TARGET_LPC176X/TOOLCHAIN_ARM_STD/: startup_LPC17xx.s sys.cpp
    ../../examples/blinky/: main.cpp
  group lpc1768_cmsis
    ../../mbed/libraries/mbed/targets/cmsis/TARGET_NXP/TARGET_LPC176X/: cmsis_nvic.c system_LPC17xx.c
  group lpc1768_hal
    ../../mbed/libraries/mbed/targets/hal/TARGET_NXP/TARGET_LPC176X/: analogin_api.c analogout_api.c can_api.c ethernet_api.c gpio_api.c gpio_irq_api.c i2c_api.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group mbed_common
    ../../mbed/libraries/mbed/common/: assert.c board.c error.c exit.c gpio.c mbed_interface.c pinmap_common.c rtc_time.c semihost_api.c us_ticker_api.c wait_api.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
